# IAR project aybr3000.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052C6 STM8L052C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\FWlib\src; ..\FWlib\inc; ..\User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: aybr3000.srec
  ILINK.IlinkOutputFile: aybr3000.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWlib
    ../FWlib/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group User
    ../User/: A7105_driver.c A7105_driver.h A7105_firmware_lib.c A7105_firmware_lib.h app_key.c app_key.h app_lcd_display.c app_lcd_display.h app_lcd_display_config.c app_lcd_display_config.h app_power.c app_power.h app_protocol.c app_protocol.h app_time.c app_time.h app_work.c app_work.h datalink_protocol.c datalink_protocol.h LCD_driver.c LCD_driver.h LCD_firmware.c LCD_firmware.h main.c main_control.c main_control.h maindef.h RTC_driver.c RTC_driver.h simple_protocol.c simple_protocol.h stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h system.c system.h task_manager.c task_manager.h timing.c timing.h types.h
